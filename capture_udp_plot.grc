options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8087'
    psize: '8192'
    type: float
    vlen: '2'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_udp_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_probe_rate_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
